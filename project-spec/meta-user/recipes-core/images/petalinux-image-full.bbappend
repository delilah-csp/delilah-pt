#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " myapp"
IMAGE_INSTALL_append = " nvme-cli"
IMAGE_INSTALL_append = " dimm-test"
IMAGE_INSTALL_append = " fio"
IMAGE_INSTALL_append = " delilah"
IMAGE_INSTALL_append = " udmabuf"
